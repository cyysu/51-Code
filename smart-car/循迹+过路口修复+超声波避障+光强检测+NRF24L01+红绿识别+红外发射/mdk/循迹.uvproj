# Keil uVision project 循迹.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 循迹 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src;..\src\DELAY;..\src\PWM;..\src\MOTOR;..\src\TIMER;..\src\UART;..\src\NRF24L01;..\src\COROL_SENSOR;..\src\DHT11;..\src\IR_CONTROL;..\src\BH1750;..\src\HC_SR04
  group User
    ./: STARTUP.A51
    ../src/: main.c
  group motor
    ../src/motor/: Car_Control.c
  group delay
    ../src/DELAY/: delay.c
  group PWM
    ../src/PWM/: PWM_PCA.c
  group Timer
    ../src/TIMER/: Timer.c
  group Uart
    ../src/UART/: uart.c
  group NRF24L01
    ../src/NRF24L01/: NRF24L01.C RC.c
  group COROL_SENSOR
    ../src/COROL_SENSOR/: color_sensor.c
  group DHT11
    ../src/DHT11/: dht11.c
  group IR
    ../src/IR_CONTROL/: Infrared_emission.c IR_control.c IR_delay.c
  group BH1750
    ../src/BH1750/: BH1750.c
  group HC_SR04
    ../src/HC_SR04/: HC_SR04.c
